# Keil uVision project M4_Drivers.uvproj, settings and files
target M4_Drivers (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: Cortex-M4 FPU ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE FPU2
  output: M4_Drivers
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\Library\Device\Nuvoton\ma35d1_rtp\Include;..\..\Library\StdDriver\inc;..\..\Library\CMSIS\Include;.\Devices
  library: MicroLIB
  link misc: --map --first='startup_ma35d1_rtp.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../Library/Device/Nuvoton/ma35d1_rtp/Source/: system_ma35d1_rtp.c
    ../../Library/Device/Nuvoton/ma35d1_rtp/Source/ARM/: startup_ma35d1_rtp.s
  group User
    ./: main.c
  group Library
    ../../Library/StdDriver/src/: clk.c gpio.c retarget.c sys.c uart.c wwdt.c
  group Devices
    ./Devices/: watchdog.c dio.c
